# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F303B HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: K9029 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\source;..\HAEDWARE\Flash;..\HAEDWARE\DELAY;..\HAEDWARE\HT1621B;..\HAEDWARE\Uart;..\HAEDWARE\Key;..\HAEDWARE\Timer;..\HAEDWARE\Pwm;..\HAEDWARE\ADC;..\HAEDWARE\WDT;..\HAEDWARE\PID
  group Source Group 1
    ./: STARTUP.A51
    ../source/: main.c
  group flash
    ../HAEDWARE/Flash/: flash.c
  group delay
    ../HAEDWARE/DELAY/: delay.c
  group ht1621b
    ../HAEDWARE/HT1621B/: ht1621b.c lcd_display.c
  group uart
    ../HAEDWARE/Uart/: uart.c
  group key
    ../HAEDWARE/Key/: key.c
  group timer
    ../HAEDWARE/Timer/: timer.c
  group pwm
    ../HAEDWARE/Pwm/: pwm.c
  group adc
    ../HAEDWARE/ADC/: adc.c
  group wdt
    ../HAEDWARE/WDT/: wdt.c
  group PID
    ../HAEDWARE/PID/: PID.c
